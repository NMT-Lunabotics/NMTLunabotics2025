Commit message: rtabmap

File: ros2_ws/src/slam_config/urdf/goliath.urdf (robot description, URDF)
Before this commit: robot goliath, 3 links, 2 joints
Joints:
- joint base_to_laser: origin xyz=0 0 0.15 rpy=0 0 0 -> xyz=0 0 0.15 rpy=0 0 3.14
